# IAR project lcd.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD_VL; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: App; Driver; STM32\CMSIS\CM3\DeviceSupport\ST\STM32F10x; STM32; STM32\STM32F10x_StdPeriph_Driver\inc; STemWin\Config; STemWin\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: lcd.srec
  ILINK.IlinkOutputFile: lcd.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group App
    App/: delay.c
  group Drivers
    Driver/: drv_lcd.c fsmc.c gpio.c rcc.c
  group STemWin/Config
    STemWin/Config/: global_includes.h GUIConf_stm3210e_eval.c GUIConf_stm3210e_eval.h LCDConf_stm3210e_eval.c LCDConf_stm3210e_eval.h
  group STemWin/inc
    STemWin/inc/: BUTTON.h BUTTON_Private.h CALENDAR.h CHECKBOX.h CHECKBOX_Private.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Intern.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h Global.h GRAPH.h GRAPH_Private.h GUI.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GIF_Private.h GUI_HOOK.h GUI_JPEG_Private.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_SIM_Win32.h GUI_SPRITE_Private.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_DCache.h GUIDRV_DCache_Private.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_FlexColor_Private.h GUIDRV_Lin.h GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_24.h GUIDRV_Lin_Opt_32.h GUIDRV_Lin_Opt_8.h GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.h GUIDRV_Template.h GUIDRV_TemplateI.h GUIDRV_TemplateI_Private.h GUIMTDRV_TangoC32.h GUITDRV_ADS7846.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h IMAGE.h IMAGE_Private.h KNOB.h KNOB_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h RADIO.h RADIO_Private.h SCROLLBAR.h SCROLLBAR_Private.h SLIDER.h SLIDER_Private.h SPINBOX.h SPINBOX_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h
  group STemWin/Lib
    STemWin/Lib/: STemWin528_CM3_IAR.a
  group STemWin/OS
    OS/: GUI_X.c
  group STM32
    STM32/: stm32f10x_it.c system_stm32f10x.c
  group STM32/cmsis
    STM32/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md_vl.s
  group STM32/stm_lib
    STM32/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_crc.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
